# Keil uVision project LCD12864.uvproj, settings and files
target IK-STC15 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LCD12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source;..\User
  group USER
    ../User/: main.c
  group SOURCE
    ../Source/: delay.c lcd12864.c key_4x4.c timer.c
  group DOC
    ../Doc/: ReadMe.txt
